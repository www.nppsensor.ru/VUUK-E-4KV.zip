# KOMPAS-3D part (éôôè-à-4èé.m3d)

Model tree:
1. Объединить компоненты:1

Referenced files in E:\Bitchkov\КОМПАС\Рабочая\ВУУК-Е (4-73)\3D\: ВУУК-Е.a3d